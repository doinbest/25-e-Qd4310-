# Keil uVision project 21F.uvprojx, settings and files
target 21F (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 21F +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../System;../System/bsp_debug;../Hardware;../Hardware/OLED;../Hardware/PID;../Hardware/KEY;../Hardware/usart2(openmv);../Hardware/usart3(maixcam);../Hardware/usart4(jy901s);../Hardware/motor;../Hardware/encoder;../Hardware/ganv-gray;../Hardware/usart5(zigbee-gray);../Hardware/led;../Hardware/drug;..\Hardware\qdrive
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Hardware/OLED/: bsp_oled.c bsp_oled.h oled_bmp.h oled_font.h
    ../Hardware/PID/: bsp_pid.c bsp_pid.h
    ../Hardware/KEY/: bsp_key.c bsp_key.h
    ../Hardware/motor/: bsp_motor.c bsp_motor.h
    ../Hardware/encoder/: bsp_encoder.c bsp_encoder.h
    ../Hardware/: control.c control.h
    ../Hardware/ganv-gray/: No_Mcu_Ganv_Grayscale_Sensor.c No_Mcu_Ganv_Grayscale_Sensor_Config.h
    ../Hardware/usart5(zigbee-gray)/: zigbee-grey.c zigbee-grey.h
    ../Hardware/usart4(jy901s)/: jy61p.c jy61p.h
    ../Hardware/usart3(maixcam)/: maixcam.c maixcam.h
    ../Hardware/qdrive/: QD4310.c QD4310.h
    ../Hardware/led/: 新建 文本文档.txt led.h led.c
  group System
    ../System/: headfile.h bsp_sys.h bsp_delay.c bsp_delay.h
    ../System/bsp_debug/: bsp_debug.c bsp_debug.h protocol.c protocol.h
software components: CMSIS:CORE 6.1.1
